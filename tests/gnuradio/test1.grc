options:
  parameters:
    generate_options: qt_gui
    id: test1
    output_language: python
    title: IQ samples Streaming
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '90000000'
    step: '10'
    stop: '1000000000'
    value: '868000000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '-70'
    step: '1'
    stop: '76'
    value: '-55'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: samp_rate
    start: '999000'
    step: '1000'
    stop: '10000000'
    value: '2000000'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: gain
    label: RF Gain
    type: int
    value: '50'
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    key: freq
    label: Frequency
    type: float
    value: '868000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    label: Relative gain
    type: complex
    update_time: '0.100'
    ymax: rf_gain
    ymin: '-110'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 350e3
    center_freq0: frequency
    dev_addr: addr=192.168.10.2
    dev_args: '""'
    gain0: '0.7'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [qtgui_edit_box_msg_0, msg, uhd_usrp_source_0, command]
- [qtgui_edit_box_msg_1, msg, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
